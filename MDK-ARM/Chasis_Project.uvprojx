# Keil uVision project Chasis_Project.uvprojx, settings and files
target Chasis_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F450VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Chasis_Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450,USE_USB_FS,USE_IRC48M
  c include: ..\Comm\Inc;..\Drivers\CMSIS\GD;..\Drivers\CMSIS\GD\GD32F4xx\Include;..\Drivers\GD32F4xx_standard_peripheral\Include;..\Function\Inc;..\HardWare\Inc;..\MotorControl\Inc;..\SystemCommon;..\User\Inc;..\Drivers\CMSIS;..\Drivers\GD32F4xx_usb_library\device\class\cdc\Include;..\Drivers\GD32F4xx_usb_library\device\core\Include;..\Drivers\GD32F4xx_usb_library\driver\Include;..\Drivers\GD32F4xx_usb_library\ustd\common;..\Drivers\GD32F4xx_usb_library\ustd\class\cdc
  memory RVCT4: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000080 size 0x3ff80
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Drivers/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group Std_Driver
    ../Drivers/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group HardWare
    ../HardWare/Src/: adc.c battery_iic.c can.c dma.c gpio.c i2c.c myiic.c tim.c usart.c gd_hal.c delay.c gpioiic.c
  group User
    ../User/Src/: main.c gd32f4xx_it.c system_gd32f4xx.c logger.c systick.c
  group Comm
    ../Comm/Src/: CanApp.c UartApp.c USBApp.c Uart_AutoChargeApp.c ringbuffer.c
  group Function
    ../Function/Src/: BootloaderInfo.c Eeprom.c ErrorLog.c Gyro.c LedDriver.c MachineAdditionalInfo.c Param.c PowerManager.c Rgb.c Temperature.c Ultrasonic.c ISTMagic.c IST8310I2C.c LeadAcidBMS.c
  group MotorControl
    ../MotorControl/Src/: Alarm.c ControlRun.c CurrentLoop.c Encoder.c Filter.c HardApi.c InnerCtrl.c PositionLoop.c SinTable.c SpeedLoop.c StateMachine.c CurrentSample.c
  group SysternCommon
    ../SystemCommon/: check_firmware.c system_common.c
  group USB_Drivers
    ../Drivers/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../Drivers/GD32F4xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../Drivers/GD32F4xx_usb_library/device/class/cdc/Source/: cdc_acm_core.c
